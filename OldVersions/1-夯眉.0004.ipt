# Autodesk Inventor part: 1-본체
## iProperties
Created: 2015-05
Part Number: 1-본체
Document SubType Name: Modeling
Designer: elite
Density: 1 g/cm^3
Author: elite
